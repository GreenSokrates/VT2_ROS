Commit message: Finished

File: src/cell_support/urdf/cell_tx260l.xacro (robot description, xacro)
@@ -23,5 +23,5 @@
     <parent link="tool0" />
     <child link="gripper_base" />
-    <origin xyz="0 0 0" rpy="0 1.57 0" />
+    <origin xyz="0 0 0" rpy="0 0 0" />
   </joint>
 </robot>
